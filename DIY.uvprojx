# Keil uVision project DIY.uvprojx, settings and files
target DIY (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DIY +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\CoreSupport;.\FreeRTOS\include;.\STM32F10x_StdPeriph_Driver\inc;.\USER;.\FreeRTOS\port
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CM3
    ./CoreSupport/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group FWL
    ./STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_i2c.c
  group RTOS
    ./FreeRTOS/: list.c queue.c tasks.c timers.c
    ./FreeRTOS/port/: heap_4.c port.c
  group USER
    ./USER/: main.c stm32f10x_it.c GUI.c Lcd_Driver.c ds3231.c i2c_soft.c bme280.c lsm303.c
